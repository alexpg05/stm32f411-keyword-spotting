#include <assert.h>
#include <stdio.h>

#include "tinykw.h"
#include "keywords.h"

#define DETECTION_THRESHOLD (128)

/* Encoding of keywords can be retrieved from https://voyelle.io/tinykw. */
// "stop", "yellow", "red", "green", "blink slow", "blink fast", "continuous"
static const uint8_t keyword_bytes[NB_KEYWORDS][48] = {
    {0xe4, 0xa7, 0x95, 0xc4, 0xf9, 0x0d, 0xb9, 0x64, 0xc5, 0xd5, 0xbb, 0xff, 0x4e, 0xf1, 0x44, 0x49, 0xa1, 0x07, 0xc6, 0x41, 0xd3, 0x40, 0x8d, 0xd5, 0x47, 0x4b, 0xe7, 0xe4, 0x26, 0x16, 0x99, 0x51, 0x3a, 0x43, 0xe4, 0x4a, 0xde, 0x9a, 0x18, 0x42, 0x83, 0x81, 0x81, 0x6b, 0xca, 0x07, 0x99, 0xaf},
    {0xff, 0x8e, 0xe9, 0xb0, 0x08, 0xa9, 0xa7, 0x50, 0x78, 0xfa, 0x48, 0x1d, 0x46, 0x4e, 0x07, 0x63, 0x04, 0x1f, 0x37, 0x34, 0x53, 0x44, 0x71, 0x95, 0xd1, 0x77, 0x05, 0xe2, 0x8b, 0x94, 0x11, 0xbd, 0xce, 0x83, 0x2f, 0x36, 0xf5, 0xb8, 0x4c, 0xe8, 0x3b, 0x85, 0xde, 0x2c, 0xff, 0xfb, 0x27, 0x2a},
    {0x96, 0x56, 0x3e, 0x38, 0x03, 0x17, 0x93, 0xa0, 0x82, 0x10, 0xf6, 0xe2, 0x9d, 0xb4, 0x5c, 0x4e, 0x6a, 0x1c, 0xda, 0xb8, 0x16, 0xc2, 0xd2, 0x41, 0x8f, 0xa0, 0x4f, 0x2c, 0x29, 0xcd, 0x1d, 0x8c, 0xbd, 0x75, 0x26, 0xfb, 0x96, 0xe7, 0xc2, 0x05, 0x73, 0xeb, 0xa3, 0x47, 0x9e, 0x4e, 0x42, 0x48},
    {0x72, 0xa2, 0xf9, 0xa4, 0x26, 0xf0, 0x85, 0x75, 0x82, 0x21, 0x05, 0x5c, 0x02, 0x3c, 0xbc, 0xe8, 0x71, 0xf1, 0x12, 0x0c, 0xf3, 0xbb, 0x64, 0xb7, 0xf3, 0xcf, 0xbb, 0x8a, 0xf4, 0x93, 0x0b, 0xfd, 0x80, 0xce, 0x14, 0xad, 0x16, 0x5f, 0xd8, 0x97, 0xa5, 0x80, 0x0e, 0x7a, 0xdd, 0xf1, 0xa3, 0xd1},
    {0x66, 0x74, 0x84, 0xe3, 0x98, 0x19, 0xd0, 0xe3, 0x68, 0x06, 0x34, 0xa9, 0x0a, 0x89, 0x83, 0x4a, 0x45, 0x57, 0xbb, 0xa1, 0xe4, 0x08, 0x88, 0x73, 0x27, 0x4e, 0xfe, 0x21, 0x89, 0x9f, 0x22, 0xfd, 0xaa, 0x65, 0x2a, 0x2b, 0x64, 0x66, 0x0c, 0x91, 0x6f, 0xc0, 0x08, 0x46, 0x7a, 0xe9, 0x67, 0x30},
    {0xfd, 0x88, 0x08, 0x74, 0x40, 0xdf, 0x00, 0x1e, 0x85, 0x85, 0xc1, 0xbe, 0xe8, 0xf2, 0x3e, 0x3f, 0x3e, 0xef, 0x00, 0x76, 0x28, 0x14, 0xf3, 0x22, 0x56, 0x95, 0x0e, 0x59, 0xfa, 0x25, 0xad, 0x3e, 0x9b, 0x69, 0x50, 0x39, 0x28, 0x5e, 0x20, 0x06, 0xf2, 0x1c, 0xa1, 0x14, 0x77, 0x12, 0x4b, 0xc3},
    {0x64, 0xa3, 0x27, 0x9b, 0x43, 0x88, 0x85, 0x39, 0xc1, 0x7a, 0xd4, 0xf4, 0x99, 0x3f, 0x49, 0x55, 0x0f, 0x89, 0x48, 0xee, 0x27, 0xc2, 0x01, 0x3d, 0xc1, 0xd5, 0x7e, 0xfc, 0xb3, 0x34, 0xe5, 0x0b, 0xe6, 0x8c, 0xd2, 0xe7, 0x47, 0x93, 0x27, 0x7d, 0x45, 0x1f, 0x5b, 0xa5, 0xd3, 0xbf, 0x5c, 0xc0},
};
static tkw_context tinykw_ctx;
static uint32_t keyword_ids[NB_KEYWORDS];

void TinyKw_Init(void)
{
	 /* Initializes TinyKW context */
	tkw_status status;
    status = tkw_init(&tinykw_ctx);
    assert(status == TKW_OK);

    /* Add the keywords to the engine */
    for (int k = 0; k < NB_KEYWORDS; ++k)
    {
        status = tkw_add_keyword(keyword_bytes[k], (uint8_t)DETECTION_THRESHOLD, &(keyword_ids[k]), &tinykw_ctx);
        assert(status == TKW_OK);
    }
}

/*
 * Process an audio frame (16-bit PCM data sampled at 16 kHz) of length TKW_AUDIO_FRAME_SIZE
 */
int TinyKw_ProcessFrame(const int16_t *audio_frame, int size)
{
	assert(size == TKW_AUDIO_FRAME_SIZE);

	tkw_status status;
    status = tkw_process_frame(audio_frame, size, &tinykw_ctx); // process one frame
    assert(status == TKW_OK);

    for (int i = 0; i < NB_KEYWORDS; ++i)
    {
        uint32_t is_detected = 0;
        status = tkw_is_keyword_detected(keyword_ids[i], &is_detected, &tinykw_ctx); // check detection
        assert(status == TKW_OK);
        if (is_detected)
        {
            status = tkw_clear_keyword_flag(i, &tinykw_ctx); // clear flag
            assert(status == TKW_OK);
            return i; // return the first detected keyword
        }
    }
    return -1; // no keyword detected
}
